IMAGE_INSTALL += "opkg"
IMAGE_INSTALL += "nano htop"
IMAGE_INSTALL += "hello-world"


